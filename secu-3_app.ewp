# IAR project secu-3_app.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 16
  ICCAVR.CCDefines: LITTLE_ENDIAN_DATA_FORMAT
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm16s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0
  General.SCCStackSize: 0x100
  General.SCRStackSize: 32
  group (top)
    sources/: adc.c adc.h bitmask.h bootldr.c bootldr.h ce_errors.c ce_errors.h ckps.c ckps.h crc16.c crc16.h eeprom.c eeprom.h fuelecon.c fuelecon.h funconv.c funconv.h idlecon.c idlecon.h ignlogic.c ignlogic.h jumper.c jumper.h knklogic.c knklogic.h knock.c knock.h magnitude.h measure.c measure.h params.c params.h procuart.c procuart.h secu3.c secu3.h starter.c starter.h suspendop.c suspendop.h tables.c tables.h uart.c uart.h ufcodes.h ventilator.c ventilator.h vstimer.c vstimer.h
